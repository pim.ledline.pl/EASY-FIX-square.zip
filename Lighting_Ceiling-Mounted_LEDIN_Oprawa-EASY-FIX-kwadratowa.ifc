Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Lighting_Ceiling-Mounted_LEDIN_Oprawa-EASY-FIX-kwadratowa.ifc
Time: 2020-11-06T08:41:47
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: Oprawa EASY-FIX kwadratowa
ePset_BIMobjectScript - Type: 6W; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Oprawa EASY-FIX kwadratowa; SKU (BO_prodsku): EASY-FIX_K; ManufacturName (BO_Manufac): LEDIN; ProductFamily (BO_prodfam): EASY-FIX; ProductGroup (BO_prodgroup): Lighting; EditionNumber (BO_edinum): 1; Width (BO_width): 0; Height (BO_height): 0; Depth (BO_depth): 0; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/ledin/product/EASY-FIX_K; ProductDataUrl (BO_prodaturl): bimobject.com/ledin/product/EASY-FIX_K; ProductUrl (BO_producturl): https://ledline.pl/produkty/kategoria/4/panele-led?series=16; MaterialMain (BO_mainmat): Plastic; BimObjectMainCategory (BO_bomaincat): Lighting; BimObjectMainCategoryCode (BO_bomaincat_code): lighting; BimObjectCategory (BO_bocat): Ceiling Mounted; BimObjectCategoryCode (BO_bocat_code): lighting-ceiling-mounted; IfcClassification (BO_ifcclas): Light Fixture; RegionEurope (BO_europe): AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, SM, UA, VA; RegionNorthAmerica (BO_northamerica): AG, AI, AW, BB, BL, BM, BQ, BS, BZ, CA, CR, CU, CW, DM, DO, GD, GL, GP, GT, HN, HT, JM, KN, KY, LC, MF, MQ, MS, MX, NI, PA, PM, PR, SV, SX, TC, TT, US, VC, VG, VI; RegionSouthAmerica (BO_southamerica): AR, BO, BR, CL, CO, EC, FK, GF, GY, PE, PY, SR, UY, VE; RegionMiddleEast (BO_middleeast): AE, AF, BH, EG, IL, IQ, IR, JO, KW, LB, OM, PS, QA, SA, SY, TR, YE; RegionAsia (BO_asia): AM, AZ, BD, BN, BT, CC, CN, CX, GE, HK, ID, IN, IO, JP, KG, KH, KP, KR, KZ, LA, LK, MM, MN, MO, MV, MY, NP, PH, PK, SG, TH, TJ, TM, TW, UZ, VN; RegionOceania (BO_oceania): AS, AU, CK, FJ, FM, GU, KI, MH, MP, NC, NF, NR, NU, NZ, PF, PG, PN, PW, SB, TK, TL, TO, TV, UM, WF, WS, VU; RegionAfrica (BO_africa): AO, BF, BI, BJ, BW, CD, CF, CG, CI, CM, CV, DJ, DZ, EH, ER, ET, GA, GH, GM, GN, GQ, GW, KE, KM, LR, LS, LY, MA, MG, ML, MR, MU, MW, MZ, NA, NE, NG, RE, RW, SC, SD, SH, SL, SN, SO, SS, ST, SZ, TD, TG, TN, TZ, UG, YT, ZA, ZM, ZW; RegionAntarctica (BO_antarctica): AQ, BV, GS, HM, TF
